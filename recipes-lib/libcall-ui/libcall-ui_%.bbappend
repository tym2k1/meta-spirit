FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-dont-set-TOP-SOURCE-DIR-to-absolute-path.patch"
